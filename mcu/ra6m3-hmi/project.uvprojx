# Keil uVision project project.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: R7FA6M3AH Renesas
  pack: Renesas.RA_DFP.3.5.0
  cpu: IRAM(0x1FFE0000,0x020000) IRAM2(0x20000000,0x080000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, __STDC_LIMIT_MACROS, RT_USING_LIBC, RT_USING_ARMLIBC
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall  -Wmissing-declarations  -Wpointer-arith  -Waggregate-return -Wfloat-equal
  c include: board\ports;..\..\apps\app_hmi_board_gui\lvgl;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\components\packages\LVGL-v8.3.9\src\draw\sw;..\..\components\packages\LVGL-v8.3.9\src\extra\themes;..\..\rtos\rt-thread\5.0.x\components\libc\posix\io\poll;..\..\rtos\rt-thread\5.0.x\components\net\sal\include\dfs_net;..\..\components\packages\LVGL-v8.3.9\src\draw\sdl;..\..\apps\app_hmi_board_gui\main;..\..\rtos\rt-thread\5.0.x\components\dfs\include;..\..\rtos\rt-thread\5.0.x\components\net\lwip\lwip-2.0.3\src\include\ipv4;libraries\HAL_Drivers\config;..\..\components\packages\LVGL-v8.3.9\src\extra\libs\rlottie;..\..\rtos\rt-thread\5.0.x\components\net\lwip\port;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\tileview;..\..\components\packages\LVGL-v8.3.9\src\extra\libs;..\..\components\packages\rw007-v2.1.0;board\lvgl\demo;..\..\rtos\rt-thread\5.0.x\components\dfs\filesystems\devfs;..\..\rtos\rt-thread\5.0.x\components\drivers\touch;..\..\components\packages\LVGL-v8.3.9\src\draw\arm2d;..\..\rtos\rt-thread\5.0.x\components\drivers\spi;..\..\components\packages\LVGL-v8.3.9\src\draw;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\led;..\..\rtos\rt-thread\5.0.x\components\net\sal\include\socket;..\..\rtos\rt-thread\5.0.x\components\libc\compilers\common\extension\fcntl\octal;..\..\components\packages\LVGL-v8.3.9\src\draw\nxp\vglite;..\..\rtos\rt-thread\5.0.x\components\net\sal\impl;..\..\components\packages\LVGL-v8.3.9\src\extra\layouts\flex;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\apps\app_hmi_board_gui\app;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\keyboard;board\lvgl;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\tabview;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\rtos\rt-thread\5.0.x\components\libc\compilers\common\include;..\..\components\packages\LVGL-v8.3.9\src\extra\themes\basic;board\ports\audio;..\..\components\packages\LVGL-v8.3.9\src;..\..\components\packages\LVGL-v8.3.9\src\extra\others\snapshot;..\..\components\packages\LVGL-v8.3.9\src\font;..\..\components\packages\LVGL-v8.3.9\src\extra\layouts;..\..\rtos\rt-thread\5.0.x\components\net\lwip\lwip-2.0.3\src\include\netif;..\..\components\packages\LVGL-v8.3.9\src\extra\others\monkey;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\animimg;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\calendar;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\span;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\colorwheel;..\..\rtos\rt-thread\5.0.x\components\net\netdev\include;..\..\rtos\rt-thread\5.0.x\components\drivers\wlan;..\..\components\packages\LVGL-v8.3.9\src\extra;..\..\components\packages\LVGL-v8.3.9\src\extra\themes\default;..\..\components\packages\LVGL-v8.3.9\src\widgets;..\..\rtos\rt-thread\5.0.x\components\net\sal\include\socket\sys_socket;..\..\components\packages\LVGL-v8.3.9\src\extra\others;..\..\components\packages\LVGL-v8.3.9\src\extra\others\gridnav;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\list;..\..\rtos\rt-thread\5.0.x\components\libc\posix\io\stdio;..\..\components\packages\LVGL-v8.3.9\src\draw\nxp\pxp;..\..\components\packages\LVGL-v8.3.9\src\extra\libs\fsdrv;..\..\components\packages\LVGL-v8.3.9\src\extra\others\imgfont;..\..\components\packages\LVGL-v8.3.9\src\extra\libs\sjpg;..\..\components\packages\LVGL-v8.3.9\env_support\rt-thread;..\..\components\packages\LVGL-v8.3.9\src\extra\others\fragment;..\..\components\packages\LVGL-v8.3.9\src\extra\layouts\grid;..\..\components\packages\LVGL-v8.3.9\src\extra\themes\mono;..\..\components\packages\LVGL-v8.3.9\src\extra\others\msg;..\..\components\packages\LVGL-v8.3.9\src\core;.;..\..\rtos\rt-thread\5.0.x\components\libc\compilers\common\extension;..\..\components\packages\LVGL-v8.3.9\src\extra\libs\qrcode;..\..\components\packages\LVGL-v8.3.9\src\extra\libs\ffmpeg;..\..\components\packages\rw007-v2.1.0\inc;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\imgbtn;..\..\rtos\rt-thread\5.0.x\libcpu\arm\cortex-m4;..\..\components\packages\LVGL-v8.3.9\src\extra\libs\freetype;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\components\packages\LVGL-v8.3.9\src\draw\swm341_dma2d;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\meter;..\..\components\packages\LVGL-v8.3.9\src\hal;..\..\components\packages\LVGL-v8.3.9\src\misc;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\win;..\..\components\packages\LVGL-v8.3.9\src\extra\libs\png;..\..\apps\app_hmi_board_gui\minIni;..\..\rtos\rt-thread\5.0.x\components\net\lwip\lwip-2.0.3\src\include;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\spinner;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets;..\..\components\packages\LVGL-v8.3.9\src\extra\libs\bmp;..\..\components\packages\LVGL-v8.3.9\src\extra\others\ime;board\ports\wifi;..\..\components\packages\LVGL-v8.3.9\src\draw\stm32_dma2d;..\..\rtos\rt-thread\5.0.x\include;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\components\packages\LVGL-v8.3.9\src\draw\renesas;..\..\rtos\rt-thread\5.0.x\components\finsh;board;board\ports\touch\gt911\inc;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\spinbox;libraries\HAL_Drivers;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\menu;user_ui_c_files;..\..\rtos\rt-thread\5.0.x\components\dfs\filesystems\elmfat;..\..\components\packages\LVGL-v8.3.9\src\extra\libs\gif;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\rtos\rt-thread\5.0.x\components\libc\posix\ipc;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\chart;..\..\components\packages\LVGL-v8.3.9\src\extra\widgets\msgbox;..\..\rtos\rt-thread\5.0.x\libcpu\arm\common;..\..\rtos\rt-thread\5.0.x\components\net\sal\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1ffe0000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\script\fsp.scat
  group Compiler
    ../../rtos/rt-thread/5.0.x/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../rtos/rt-thread/5.0.x/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../rtos/rt-thread/5.0.x/libcpu/arm/common/: div0.c showmem.c
    ../../rtos/rt-thread/5.0.x/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../rtos/rt-thread/5.0.x/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../rtos/rt-thread/5.0.x/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rtos/rt-thread/5.0.x/components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../rtos/rt-thread/5.0.x/components/drivers/rtc/: rtc.c soft_rtc.c
    ../../rtos/rt-thread/5.0.x/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../rtos/rt-thread/5.0.x/components/drivers/serial/: serial_v2.c
    ../../rtos/rt-thread/5.0.x/components/drivers/spi/: spi_core.c spi_dev.c spi_wifi_rw009.c
    ../../rtos/rt-thread/5.0.x/components/drivers/touch/: touch.c
    ../../rtos/rt-thread/5.0.x/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/ports/: drv_g2d.c drv_jpeg.c mnt.c
    board/ports/wifi/: drv_rw007.c
    board/: ra6m3_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_pwm.c drv_sci_spi.c drv_sdhi.c drv_soft_i2c.c drv_spi.c drv_usart_v2.c
  group Filesystem
    ../../rtos/rt-thread/5.0.x/components/dfs/filesystems/devfs/: devfs.c
    ../../rtos/rt-thread/5.0.x/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../rtos/rt-thread/5.0.x/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../rtos/rt-thread/5.0.x/components/finsh/: msh_file.c shell.c msh.c msh_parse.c cmd.c
  group gt911
    board/ports/touch/gt911/src/: gt911.c
  group Kernel
    ../../rtos/rt-thread/5.0.x/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group LVGL
    ../../components/packages/LVGL-v8.3.9/src/draw/sdl/: lv_draw_sdl_mask.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_label.c lv_draw_sdl_polygon.c lv_draw_sdl.c lv_draw_sdl_layer.c lv_draw_sdl_texture_cache.c lv_draw_sdl_composite.c lv_draw_sdl_line.c lv_draw_sdl_img.c lv_draw_sdl_utils.c lv_draw_sdl_stack_blur.c lv_draw_sdl_rect.c
    ../../components/packages/LVGL-v8.3.9/src/misc/: lv_templ.c lv_utils.c lv_tlsf.c lv_lru.c lv_anim_timeline.c lv_fs.c lv_mem.c lv_ll.c lv_timer.c lv_log.c lv_style.c lv_anim.c lv_txt.c lv_style_gen.c lv_async.c lv_color.c lv_bidi.c lv_txt_ap.c lv_gc.c lv_area.c lv_printf.c lv_math.c
    ../../components/packages/LVGL-v8.3.9/src/widgets/: lv_table.c lv_btnmatrix.c lv_label.c lv_checkbox.c lv_slider.c lv_arc.c lv_roller.c lv_dropdown.c lv_btn.c lv_img.c lv_line.c lv_objx_templ.c lv_canvas.c lv_bar.c lv_switch.c lv_textarea.c
    ../../components/packages/LVGL-v8.3.9/src/extra/libs/gif/: lv_gif.c gifdec.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_dropdown.c lv_calendar_header_arrow.c
    ../../components/packages/LVGL-v8.3.9/src/draw/: lv_draw_triangle.c lv_draw_transform.c lv_draw.c lv_draw_layer.c lv_draw_arc.c lv_draw_label.c lv_img_buf.c lv_draw_mask.c lv_draw_img.c lv_draw_rect.c lv_draw_line.c lv_img_cache.c lv_img_decoder.c
    ../../components/packages/LVGL-v8.3.9/src/font/: lv_font_montserrat_18.c lv_font_unscii_16.c lv_font_montserrat_8.c lv_font_montserrat_38.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_20.c lv_font_montserrat_48.c lv_font_fmt_txt.c lv_font_montserrat_40.c lv_font_montserrat_34.c lv_font_montserrat_26.c lv_font_simsun_16_cjk.c lv_font_loader.c lv_font_montserrat_24.c lv_font_montserrat_42.c lv_font_montserrat_16.c lv_font_montserrat_12_subpx.c lv_font_montserrat_32.c lv_font_montserrat_10.c lv_font_montserrat_22.c lv_font_montserrat_36.c lv_font_montserrat_28.c lv_font_montserrat_46.c lv_font_montserrat_14.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_12.c lv_font_unscii_8.c lv_font.c lv_font_montserrat_44.c
    ../../components/packages/LVGL-v8.3.9/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite.c lv_vglite_buf.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_draw_vglite_line.c lv_vglite_utils.c
    ../../components/packages/LVGL-v8.3.9/src/extra/libs/png/: lv_png.c lodepng.c
    ../../components/packages/LVGL-v8.3.9/src/draw/sw/: lv_draw_sw_letter.c lv_draw_sw_polygon.c lv_draw_sw_blend.c lv_draw_sw_arc.c lv_draw_sw.c lv_draw_sw_img.c lv_draw_sw_line.c lv_draw_sw_transform.c lv_draw_sw_rect.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_layer.c
    ../../components/packages/LVGL-v8.3.9/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/spinner/: lv_spinner.c
    ../../components/packages/LVGL-v8.3.9/src/core/: lv_indev.c lv_obj_scroll.c lv_indev_scroll.c lv_obj_class.c lv_disp.c lv_obj_pos.c lv_obj_style.c lv_obj.c lv_obj_style_gen.c lv_theme.c lv_obj_tree.c lv_obj_draw.c lv_refr.c lv_group.c lv_event.c
    ../../components/packages/LVGL-v8.3.9/src/draw/renesas/: lv_gpu_d2_ra6m3.c lv_gpu_d2_draw_label.c
    ../../components/packages/LVGL-v8.3.9/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../components/packages/LVGL-v8.3.9/src/extra/others/monkey/: lv_monkey.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/span/: lv_span.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/chart/: lv_chart.c
    ../../components/packages/LVGL-v8.3.9/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_draw_pxp.c lv_gpu_nxp_pxp_osa.c
    ../../components/packages/LVGL-v8.3.9/src/extra/others/msg/: lv_msg.c
    ../../components/packages/LVGL-v8.3.9/src/extra/libs/rlottie/: lv_rlottie.c
    ../../components/packages/LVGL-v8.3.9/src/extra/libs/bmp/: lv_bmp.c
    ../../components/packages/LVGL-v8.3.9/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../components/packages/LVGL-v8.3.9/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../../components/packages/LVGL-v8.3.9/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    ../../components/packages/LVGL-v8.3.9/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/win/: lv_win.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/tabview/: lv_tabview.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/tileview/: lv_tileview.c
    ../../components/packages/LVGL-v8.3.9/src/extra/libs/freetype/: lv_freetype.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/meter/: lv_meter.c
    ../../components/packages/LVGL-v8.3.9/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_stdio.c lv_fs_posix.c lv_fs_win32.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../components/packages/LVGL-v8.3.9/src/extra/themes/basic/: lv_theme_basic.c
    ../../components/packages/LVGL-v8.3.9/src/hal/: lv_hal_tick.c lv_hal_disp.c lv_hal_indev.c
    ../../components/packages/LVGL-v8.3.9/src/extra/layouts/flex/: lv_flex.c
    ../../components/packages/LVGL-v8.3.9/src/extra/others/imgfont/: lv_imgfont.c
    ../../components/packages/LVGL-v8.3.9/src/extra/layouts/grid/: lv_grid.c
    ../../components/packages/LVGL-v8.3.9/src/extra/others/gridnav/: lv_gridnav.c
    ../../components/packages/LVGL-v8.3.9/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../components/packages/LVGL-v8.3.9/src/extra/themes/mono/: lv_theme_mono.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/animimg/: lv_animimg.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/menu/: lv_menu.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../components/packages/LVGL-v8.3.9/src/extra/others/ime/: lv_ime_pinyin.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/list/: lv_list.c
    ../../components/packages/LVGL-v8.3.9/src/extra/widgets/led/: lv_led.c
    ../../components/packages/LVGL-v8.3.9/src/extra/others/snapshot/: lv_snapshot.c
    ../../components/packages/LVGL-v8.3.9/src/extra/themes/default/: lv_theme_default.c
    ../../components/packages/LVGL-v8.3.9/src/extra/: lv_extra.c
  group LVGL-demo
    ../../apps/app_hmi_board_gui/lvgl/: lv_user_demo.c
    ../../apps/app_hmi_board_gui/lvgl/user_events/: events_mainscreen.c events_quweidonghua.c events_shuxueyunsuan.c events_welcome.c events_xitongshezhi.c events_yingyuqimeng.c events_yuwenbaozang.c evetns_zhinengai.c
    ../../apps/app_hmi_board_gui/lvgl/user_ui_c_files/components/: ui_comp_hook.c
    ../../apps/app_hmi_board_gui/lvgl/user_ui_c_files/fonts/: ui_font_chnfont.c
    ../../apps/app_hmi_board_gui/lvgl/user_ui_c_files/images/: ui_img_bg_img_png.c ui_img_fengmian_png.c
    ../../apps/app_hmi_board_gui/lvgl/user_ui_c_files/screens/: ui_mainscreen.c ui_quweidonghua.c ui_shuxueyunsuan.c ui_welcomescreen.c ui_xitongshezhi.c ui_yingyuqimeng.c ui_yuwenbaozang.c ui_zhinengai.c
    ../../apps/app_hmi_board_gui/lvgl/user_ui_c_files/: ui.c ui_helpers.c
    board/lvgl/demo/: lv_demo.c
  group LVGL-port
    ../../components/packages/LVGL-v8.3.9/env_support/rt-thread/: lv_rt_thread_port.c
    board/lvgl/: lv_port_disp.c lv_port_indev.c
  group lwIP
    ../../rtos/rt-thread/5.0.x/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rtos/rt-thread/5.0.x/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../rtos/rt-thread/5.0.x/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../rtos/rt-thread/5.0.x/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../rtos/rt-thread/5.0.x/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../rtos/rt-thread/5.0.x/components/net/lwip/port/: ethernetif.c sys_arch.c
  group main
    ../../apps/app_hmi_board_gui/main/: app_main.c
  group minIni
    ../../apps/app_hmi_board_gui/minIni/: minIni.c
  group POSIX
    ../../rtos/rt-thread/5.0.x/components/libc/posix/io/stdio/: libc.c
  group rw007
    ../../components/packages/rw007-v2.1.0/src/: spi_wifi_rw007.c
  group SAL
    ../../rtos/rt-thread/5.0.x/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../rtos/rt-thread/5.0.x/components/net/sal/dfs_net/: dfs_net.c
    ../../rtos/rt-thread/5.0.x/components/net/sal/impl/: af_inet_lwip.c
    ../../rtos/rt-thread/5.0.x/components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../rtos/rt-thread/5.0.x/components/net/sal/src/: sal_socket.c
  group user_app
    ../../apps/app_hmi_board_gui/app/: app_wifi.c app.c app_led.c app_file_ini.c app_ai_chat.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
